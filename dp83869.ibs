| From dp83869.ibs, DP83869, TI
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|   gpio_0000_1p8 Model
[Model]   gpio_0000_1p8
Model_type   I/O
Polarity   Non-Inverting
Enable   Active-Low
Vinl = 0.344
Vinh = 1.204
Vmeas = 0.9
Vref = 0
Cref = 2pF
Rref = 100000
|   typ   min   max
C_comp   1.311pF   1.163pF   1.492pF
| Where Nom  PVT is Nominal Process, 1.8V,  27C
|   Fast PVT is Strong Process,  1.89V, -40C
|   Slow PVT is Weak Process,   1.71V, 125C
[Voltage Range]   1.8   1.71   1.89
|Junction Temperature
[Temperature Range]   27   125   -40
[Pullup Reference]   1.8   1.71   1.89
[Pulldown Reference]   -0   -0   -0
[Power Clamp Reference]   1.8   1.71   1.89
[GND Clamp Reference]   0   0   0
| Worked out from all points:
|   slope of the pulldown table from 0 to 0.27 V, typ, clamps not added: 88.9 ohm
|   slope of the pullup table from 0 to 0.27 V, typ, clamps not added: 95.7 ohm
|   GND clamp passes 1 mA (typ) near -0.32 V on its own axis
|   POWER clamp passes 1 mA (typ) near -0.31 V on its own axis
|   falling waveform, V_fixture 1.8V, R_fixture 300Ohm: 20-80 % time 310ps typ, 375ps min, 269ps max; typ from 1.78 V to 0.412 V
|   rising waveform, V_fixture 0V, R_fixture 300Ohm: 20-80 % time 363ps typ, 559ps min, 265ps max; typ from 0 V to 1.35 V
|   rising waveform, V_fixture 1.8V, R_fixture 300Ohm: 20-80 % time 380ps typ, 660ps min, 259ps max; typ from 0.412 V to 1.78 V
|   falling waveform, V_fixture 0V, R_fixture 300Ohm: 20-80 % time 346ps typ, 411ps min, 298ps max; typ from 1.35 V to 0 V
[Pulldown]
-1.2V     -5.499mA   -4.573mA   -6.639mA
-1.2V     -5.499mA   -5.651mA   -6.639mA
-1.199V   -5.498mA   -5.912mA   -6.637mA
-1.191V   -5.487mA   -5.013mA   -6.623mA
-1.188V   -5.484mA   -5.049mA   -6.619mA
-1.188V   -5.483mA   -5.895mA   -6.618mA
-469mV    -4.445mA   -3.68mA    -5.363mA
-149.6mV  -1.689mA   -1.401mA   -2.058mA
1.951V    21.57mA    17.26mA    26.52mA
2.105V    24mA       18.81mA    28.86mA
2.436V    29.25mA    22.15mA    35.68mA
3V        36.18mA    22.13mA    45.08mA
[GND Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-1.2V     -67.24mA   -52.42mA   -82.2mA
-1.087V   -46.83mA   -36.17mA   -58.76mA
-994.8mV  -31.76mA   -25.29mA   -39.68mA
-965mV    -27.36mA   -22.7mA    -33.5mA
-896.4mV  -18.99mA   -16.76mA   -22.27mA
-837.8mV  -14.14mA   -13.09mA   -15.9mA
-780.2mV  -10.96mA   -9.504mA   -13.19mA
-671.4mV  -7.107mA   -5.596mA   -9.092mA
-441.1mV  -1.679mA   -1.37mA    -2.108mA
-326.3mV  -1.018mA   -832uA     -286.6uA
-149.6mV  -2.221uA   -4.052uA   -2.266uA
3V        0A         0A         0A
[Pullup]
|   Voltage   I(typ)   I(min)   I(max)
-1.2V     8.893mA    6.738mA    10.4mA
-1.2V     8.893mA    7.547mA    10.4mA
-1.199V   8.889mA    7.763mA    10.4mA
-1.191V   8.855mA    6.994mA    10.39mA
-1.188V   8.846mA    7.02mA     10.38mA
-1.188V   8.846mA    7.632mA    10.38mA
-1.188V   8.843mA    7.713mA    10.38mA
-659.1mV  6.695mA    5.741mA    7.964mA
-386.7mV  4.208mA    3.461mA    5.638mA
1.95V     -19.67mA   -15.93mA   -24.2mA
2.411V    -23.81mA   -18.93mA   -29.43mA
3V        -29.09mA   -21.13mA   -36.19mA
[POWER Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-1.2V     57.06mA    40.03mA    79.18mA
-1.112V   39.42mA    29.97mA    55.94mA
-1.038V   27.78mA    23.2mA     38.38mA
-1.012V   24.87mA    20.79mA    32.41mA
-946.7mV  17.7mA     15.74mA    21.63mA
-872.3mV  11.85mA    10.61mA    13.9mA
-845.4mV  9.819mA    9.193mA    12.69mA
-786.2mV  7.821mA    6.665mA    10.02mA
-492mV    2.078mA    1.587mA    3.049mA
-321.2mV  1.043mA    798.9uA    549.7uA
-149.6mV  3.245uA    7.476uA    3.477uA
3V        0A         0A         0A
[Ramp]
R_load = 300
|   typ   min   max
dV/dt_r   0.807477/3.60374e-10   0.725388/5.58566e-10   0.888845/2.6221e-10
dV/dt_f   0.824068/3.08968e-10   0.745168/3.73078e-10   0.902949/2.67201e-10
[Falling Waveform]
V_fixture = 1.8V
V_fixture_min = 1.71V
V_fixture_max = 1.89V
R_fixture = 300Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        1.785V     1.695V     1.874V
449.4ps   1.805V     1.702V     1.959V
649.9ps   1.86V      1.709V     1.062V
761.4ps   1.529V     1.713V     757mV
926.7ps   948.4mV    1.734V     538.7mV
1.047ns   726.5mV    1.761V     462.4mV
1.13ns    633.2mV    1.629V     426.1mV
1.474ns   463.6mV    815.8mV    383.6mV
1.916ns   422.5mV    526.8mV    374.2mV
5ns       411.6mV    453.3mV    369.3mV
[Rising Waveform]
V_fixture = 0V
V_fixture_min = 0V
V_fixture_max = 0V
R_fixture = 300Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        172.7uV    412uV      126.1uV
419.9ps   -100.9mV   -61.79mV   -51.22mV
617.8ps   14.97mV    -76.57mV   538.8mV
795.8ps   372.1mV    -37.07mV   1.145V
916.4ps   670.9mV    6.982mV    1.327V
1.088ns   1.042V     119.9mV    1.422V
1.302ns   1.237V     380.6mV    1.456V
1.718ns   1.319V     933.1mV    1.471V
2.078ns   1.334V     1.124V     1.474V
5ns       1.346V     1.209V     1.482V
[Rising Waveform]
V_fixture = 1.8V
V_fixture_min = 1.71V
V_fixture_max = 1.89V
R_fixture = 300Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        411.6mV    453.3mV    369.3mV
306.2ps   374.4mV    435.2mV    371.4mV
457.6ps   572.9mV    506.1mV    701.7mV
642.6ps   897.9mV    778mV      1.399V
705.6ps   1.042V     859.2mV    1.575V
841.6ps   1.391V     1.01V      1.755V
961.8ps   1.589V     1.125V     1.817V
1.321ns   1.751V     1.517V     1.857V
1.603ns   1.768V     1.64V      1.865V
5ns       1.785V     1.695V     1.874V
[Falling Waveform]
|Gnd
V_fixture = 0V
V_fixture_min = 0V
V_fixture_max = 0V
R_fixture = 300Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        1.346V     1.21V      1.482V
449.4ps   1.365V     1.218V     1.563V
649.9ps   1.414V     1.222V     735.4mV
885.6ps   654mV      1.231V     229.6mV
1.047ns   345mV      1.258V     99.52mV
1.14ns    235.7mV    1.086V     61.1mV
1.295ns   117.7mV    648mV      34.52mV
1.458ns   59.79mV    380.9mV    17.59mV
1.936ns   13.47mV    70.91mV    4.391mV
5ns       171.4uV    408.8uV    125.6uV
